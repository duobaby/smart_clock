# Keil uVision project clock.uvprojx, settings and files
target clock (6130001::V6.13.1::.\ARMCLANG)
  device: ARMCM4 ARM
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: clock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F411xE,USE_HAL_DRIVER
  c include: bsp\inc;Core\Inc;Drivers\STM32F4xx_HAL_Driver\Inc;Drivers\cmsis\Include;rtt;rtt\include;rtt\include\libc;rtt\components\finsh;lvgl\porting;lvgl\src;lvgl;thread_app\inc;app\page_controller_app;app\thread_app;app\ui_app
  asm define: STM32F411xE,USE_HAL_DRIVER
  memory RVCT1: ROM 0x08000000 size 0x80000
  memory RVCT6: RAM 0x20000000 size 0x20000
  group RTT
    rtt/: board.c
  group RTT/SRC
    rtt/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTT/PORTS
    rtt/ports/: context_rvds.S cpuport.c
  group RTT/COMPONENTS/FINSH
    rtt/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group RTT/COMPONENTS/DEVICE
    rtt/components/device/: device.c
  group STARTUP
    startup/: startup_stm32f411xe.s
  group LVGL/SRC/WIDGETS
    lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/SRC/MISC
    lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/SRC/HAL
    lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/SRC/FONT
    lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group LVGL/SRC/EXTRA
    lvgl/src/extra/: lv_extra.c
  group LVGL/SRC/EXTRA/WIDGETS/WIN
    lvgl/src/extra/widgets/win/: lv_win.c
  group LVGL/SRC/EXTRA/WIDGETS/TILEVIEW
    lvgl/src/extra/widgets/tileview/: lv_tileview.c
  group LVGL/SRC/EXTRA/WIDGETS/TABVIEW
    lvgl/src/extra/widgets/tabview/: lv_tabview.c
  group LVGL/SRC/EXTRA/WIDGETS/SPINNER
    lvgl/src/extra/widgets/spinner/: lv_spinner.c
  group LVGL/SRC/EXTRA/WIDGETS/SPINBOX
    lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
  group LVGL/SRC/EXTRA/WIDGETS/SPAN
    lvgl/src/extra/widgets/span/: lv_span.c
  group LVGL/SRC/EXTRA/WIDGETS/MSGBOX
    lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
  group LVGL/SRC/EXTRA/WIDGETS/METER
    lvgl/src/extra/widgets/meter/: lv_meter.c
  group LVGL/SRC/EXTRA/WIDGETS/MENU
    lvgl/src/extra/widgets/menu/: lv_menu.c
  group LVGL/SRC/EXTRA/WIDGETS/LIST
    lvgl/src/extra/widgets/list/: lv_list.c
  group LVGL/SRC/EXTRA/WIDGETS/LED
    lvgl/src/extra/widgets/led/: lv_led.c
  group LVGL/SRC/EXTRA/WIDGETS/KEYBOARD
    lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
  group LVGL/SRC/EXTRA/WIDGETS/IMGBTN
    lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group LVGL/SRC/EXTRA/WIDGETS/COLORWHEEL
    lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
  group LVGL/SRC/EXTRA/WIDGETS/CHART
    lvgl/src/extra/widgets/chart/: lv_chart.c
  group LVGL/SRC/EXTRA/WIDGETS/CALENDAR
    lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group LVGL/SRC/EXTRA/WIDGETS/ANIMIMG
    lvgl/src/extra/widgets/animimg/: lv_animimg.c
  group LVGL/SRC/EXTRA/THEMES/MONO
    lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group LVGL/SRC/EXTRA/THEMES/DEFAULT
    lvgl/src/extra/themes/default/: lv_theme_default.c
  group LVGL/SRC/EXTRA/THEMES/BASIC
    lvgl/src/extra/themes/basic/: lv_theme_basic.c
  group LVGL/SRC/EXTRA/OTHERS/SNAPSHOT
    lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group LVGL/SRC/EXTRA/OTHERS/MONKEY
    lvgl/src/extra/others/monkey/: lv_monkey.c
  group LVGL/SRC/EXTRA/OTHERS/GRIDNAV
    lvgl/src/extra/others/gridnav/: lv_gridnav.c
  group LVGL/SRC/EXTRA/LIBS/SJPG
    lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
  group LVGL/SRC/EXTRA/LIBS/RLOTTIE
    lvgl/src/extra/libs/rlottie/: lv_rlottie.c
  group LVGL/SRC/EXTRA/LIBS/QRCODE
    lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group LVGL/SRC/EXTRA/LIBS/PNG
    lvgl/src/extra/libs/png/: lodepng.c lv_png.c
  group LVGL/SRC/EXTRA/LIBS/GIF
    lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
  group LVGL/SRC/EXTRA/LIBS/FSDRV
    lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group LVGL/SRC/EXTRA/LIBS/FREETYPE
    lvgl/src/extra/libs/freetype/: lv_freetype.c
  group LVGL/SRC/EXTRA/LIBS/FFMPEG
    lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
  group LVGL/SRC/EXTRA/LIBS/BMP
    lvgl/src/extra/libs/bmp/: lv_bmp.c
  group LVGL/SRC/EXTRA/LAYOUTS/GRID
    lvgl/src/extra/layouts/grid/: lv_grid.c
  group LVGL/SRC/EXTRA/LAYOUTS/FLEX
    lvgl/src/extra/layouts/flex/: lv_flex.c
  group LVGL/SRC/DRAW
    lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL/SRC/DRAW/SW
    lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group LVGL/SRC/DRAW/STM32_DMA2D
    lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group LVGL/SRC/DRAW/SDL
    lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group LVGL/SRC/DRAW/NXP_VGLITE
    lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
  group LVGL/SRC/DRAW/NXP_PXP
    lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
  group LVGL/SRC/CORE
    lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/PORTING
    lvgl/porting/: lv_port_disp.cpp lv_port_indev.cpp
  group thread_app/src
    app/thread_app/: thread_lvgl.cpp
    app/page_controller_app/: PageManager.cpp
  group driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group core
    Core/Src/: delay.cpp main.cpp spi.cpp stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group bsp
    bsp/src/: lcd.cpp tp.cpp
